# Keep ffmpeg as in the NXP BSP (meta-python-ai enables these with vulkan)
PACKAGECONFIG:remove = "libplacebo shaderc"
