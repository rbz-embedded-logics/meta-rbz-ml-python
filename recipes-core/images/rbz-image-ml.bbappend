IMAGE_INSTALL += "packagegroup-rbz-ml-python"
